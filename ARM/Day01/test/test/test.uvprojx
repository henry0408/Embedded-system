# Keil uVision project test.uvprojx, settings and files
target Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc;..\Lib_BSP\inc;..\Lib_MCU\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group User
    ./Src/: main.c speaker.c
    ./: led.c fan.c DHT11.c
    ./Inc/: speaker.h
  group Board
    ../Lib_MCU/src/: gpio.c ssp.c
  group Peripheral
    ../Lib_BSP/src/: tools.c oled2864.c
  group System
    ../Lib_MCU/src/: startup_LPC11xx.s system_LPC11xx.c
